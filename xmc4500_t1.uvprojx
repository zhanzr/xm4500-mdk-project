# Keil uVision project xmc4500_t1.uvprojx, settings and files
target XMC4500 Relax Kit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.11.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UART_transmit
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c include: G:\Keil_v5\ARM\PACK\ARM\CMSIS\5.5.1\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT8: RAM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x30000000 size 0x8000
  group Source Files
    ./: main.c low_pass_filter.c sine_generator.c
    G:/Keil_v5/ARM/PACK/ARM/CMSIS/5.5.1/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group Documentation
    ./: README.md
software components: RTOS:Config 10.2.0, RTOS:Core 10.2.0, RTOS:Heap 10.2.0, CMSIS:CORE 5.2.0, CMSIS Driver:USART 2.11, Device:RTE_Device 1.1.0, Device:Startup 2.2.0, Device:XMClib:GPIO 2.1.18, Device:XMClib:SCU 2.1.18, Device:XMClib:UART 2.1.18, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, Data Exchange:JSON:Jansson 2.7.0, Data Exchange:JSON:cJSON 1.7.7, Data Exchange:JSON:parson 0.0.0
